# IAR project client.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: QN9020 Quintic QN9020
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: IAR_CC
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\src; ..\..\src\app; ..\..\src\app\basc; ..\..\src\app\blpc; ..\..\src\app\disc; ..\..\src\app\findl; ..\..\src\app\gap; ..\..\src\app\gatt; ..\..\src\app\glpc; ..\..\src\app\hrpc; ..\..\src\app\htpc; ..\..\src\app\proxm; ..\..\src\app\scppc; ..\..\src\app\smp; ..\..\src\app\tipc; ..\..\src\cmsis; ..\..\src\driver; ..\..\src\fw; ..\..\src\lib; ..\..\src\profiles; ..\..\src\profiles\bas\basc; ..\..\src\profiles\blp; ..\..\src\profiles\blp\blpc; ..\..\src\profiles\blp\blps; ..\..\src\profiles\dis\disc; ..\..\src\profiles\find\findl; ..\..\src\profiles\glp; ..\..\src\profiles\glp\glpc; ..\..\src\profiles\glp\glps; ..\..\src\profiles\hrp; ..\..\src\profiles\hrp\hrpc; ..\..\src\profiles\htp; ..\..\src\profiles\htp\htpc; ..\..\src\profiles\prox\proxm; ..\..\src\profiles\scpp; ..\..\src\profiles\scpp\scppc; ..\..\src\profiles\tip; ..\..\src\profiles\tip\tipc; ..\..\src\qnevb; ..\..\src\app\anpc; ..\..\src\app\cscpc; ..\..\src\app\paspc; ..\..\src\app\rscpc; ..\..\src\profiles\anp; ..\..\src\profiles\anp\anpc; ..\..\src\profiles\cscp; ..\..\src\profiles\cscp\cscpc; ..\..\src\profiles\pasp; ..\..\src\profiles\pasp\paspc; ..\..\src\profiles\rscp; ..\..\src\profiles\rscp\rscpc; ..\..\src\profiles\hogp; ..\..\src\profiles\hogp\hogpbh; ..\..\src\profiles\hogp\hogprh; ..\..\src\app\hogpbh; ..\..\src\app\hogprh; ..\..\src\app\qppc; ..\..\src\app\qpps; ..\..\src\profiles\qpp; ..\..\src\profiles\qpp\qppc; ..\..\src\profiles\qpp\qpps
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: client.bin
  ILINK.IlinkOutputFile: client.out
  ILINK.IlinkIcfFile: ..\..\src\link\iar\qn9020_link.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptStrategy: 0
  group app
    ../../src/app/anpc/: app_anpc.c app_anpc_task.c
    ../../src/app/basc/: app_basc.c app_basc_task.c
    ../../src/app/blpc/: app_blpc.c app_blpc_task.c
    ../../src/app/cscpc/: app_cscpc.c app_cscpc_task.c
    ../../src/app/disc/: app_disc.c app_disc_task.c
    ../../src/app/: app_env.c app_menu.c app_printf.c app_sys.c app_task.c app_util.c
    ../../src/app/findl/: app_findl.c app_findl_task.c
    ../../src/app/gap/: app_gap.c app_gap_task.c
    ../../src/app/gatt/: app_gatt.c app_gatt_task.c
    ../../src/app/glpc/: app_glpc.c app_glpc_task.c
    ../../src/app/hogpbh/: app_hogpbh.c app_hogpbh_task.c
    ../../src/app/hogprh/: app_hogprh.c app_hogprh_task.c
    ../../src/app/hrpc/: app_hrpc.c app_hrpc_task.c
    ../../src/app/htpc/: app_htpc.c app_htpc_task.c
    ../../src/app/paspc/: app_paspc.c app_paspc_task.c
    ../../src/app/proxm/: app_proxm.c app_proxm_task.c
    ../../src/app/qppc/: app_qppc.c app_qppc_task.c
    ../../src/app/rscpc/: app_rscpc.c app_rscpc_task.c
    ../../src/app/scppc/: app_scppc.c app_scppc_task.c
    ../../src/app/smp/: app_smp.c app_smp_task.c
    ../../src/app/tipc/: app_tipc.c app_tipc_task.c
  group drivers
    ../../src/driver/: dma.c gpio.c rtc.c serialflash.c sleep.c syscon.c timer.c uart.c
  group lib
    ../../src/lib/iar/: qn9020b2_lib_allroles.a
  group main
    ../../src/main/: app_main.c
  group profiles
    ../../src/profiles/anp/anpc/: anpc.c anpc_task.c
    ../../src/profiles/bas/basc/: basc.c basc_task.c
    ../../src/profiles/blp/blpc/: blpc.c blpc_task.c
    ../../src/profiles/cscp/cscpc/: cscpc.c cscpc_task.c
    ../../src/profiles/dis/disc/: disc.c disc_task.c
    ../../src/profiles/find/findl/: findl.c findl_task.c
    ../../src/profiles/glp/glpc/: glpc.c glpc_task.c
    ../../src/profiles/hogp/hogpbh/: hogpbh.c hogpbh_task.c
    ../../src/profiles/hogp/hogprh/: hogprh.c hogprh_task.c
    ../../src/profiles/hrp/hrpc/: hrpc.c hrpc_task.c
    ../../src/profiles/htp/htpc/: htpc.c htpc_task.c
    ../../src/profiles/pasp/paspc/: paspc.c paspc_task.c
    ../../src/profiles/: prf_utils.c
    ../../src/profiles/prox/proxm/: proxm.c proxm_task.c
    ../../src/profiles/qpp/qppc/: qppc.c qppc_task.c
    ../../src/profiles/rscp/rscpc/: rscpc.c rscpc_task.c
    ../../src/profiles/scpp/scppc/: scppc.c scppc_task.c
    ../../src/profiles/tip/tipc/: tipc.c tipc_task.c
  group qnevb
    ../../src/qnevb/: led.c
  group retarget
    ../../src/retarget/: retarget.c
  group startup
    ../../src/startup/iar/: startup.s
  group usr
    ../src/: system.c usr_design.c
