# IAR project eaci_controller.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: QN9020 Quintic QN9020
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: IAR_CC
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\src\fw; ..\..\src\profiles; ..\..\src\profiles\anp; ..\..\src\profiles\anp\anpc; ..\..\src\profiles\anp\anps; ..\..\src\profiles\bas\basc; ..\..\src\profiles\bas\bass; ..\..\src\profiles\blp; ..\..\src\profiles\blp\blpc; ..\..\src\profiles\blp\blps; ..\..\src\profiles\cscp; ..\..\src\profiles\cscp\cscpc; ..\..\src\profiles\cscp\cscps; ..\..\src\profiles\dis\disc; ..\..\src\profiles\dis\diss; ..\..\src\profiles\find\findl; ..\..\src\profiles\find\findt; ..\..\src\profiles\glp; ..\..\src\profiles\glp\glpc; ..\..\src\profiles\glp\glps; ..\..\src\profiles\hogp; ..\..\src\profiles\hogp\hogpbh; ..\..\src\profiles\hogp\hogpd; ..\..\src\profiles\hogp\hogprh; ..\..\src\profiles\hrp; ..\..\src\profiles\hrp\hrpc; ..\..\src\profiles\hrp\hrps; ..\..\src\profiles\htp; ..\..\src\profiles\htp\htpc; ..\..\src\profiles\htp\htpt; ..\..\src\profiles\pasp; ..\..\src\profiles\pasp\paspc; ..\..\src\profiles\pasp\pasps; ..\..\src\profiles\prox\proxm; ..\..\src\profiles\prox\proxr; ..\..\src\profiles\rscp; ..\..\src\profiles\rscp\rscpc; ..\..\src\profiles\rscp\rscps; ..\..\src\profiles\scpp; ..\..\src\profiles\scpp\scppc; ..\..\src\profiles\scpp\scpps; ..\..\src\profiles\tip; ..\..\src\profiles\tip\tipc; ..\..\src\profiles\tip\tips; ..\..\src\app; ..\src; ..\..\src\app\anpc; ..\..\src\app\anps; ..\..\src\app\basc; ..\..\src\app\bass; ..\..\src\app\blpc; ..\..\src\app\blps; ..\..\src\app\cscpc; ..\..\src\app\cscps; ..\..\src\app\disc; ..\..\src\app\diss; ..\..\src\app\findl; ..\..\src\app\findt; ..\..\src\app\glpc; ..\..\src\app\glps; ..\..\src\app\hrpc; ..\..\src\app\hrps; ..\..\src\app\paspc; ..\..\src\app\pasps; ..\..\src\app\proxr; ..\..\src\app\proxm; ..\..\src\app\hogpbh; ..\..\src\app\hogpd; ..\..\src\app\hogprh; ..\..\src\app\htpc; ..\..\src\app\htpt; ..\..\src\app\rscpc; ..\..\src\app\rscps; ..\..\src\app\scppc; ..\..\src\app\scpps; ..\..\src\app\tipc; ..\..\src\app\tips; ..\..\src\app\gap; ..\..\src\app\gatt; ..\..\src\app\smp; ..\..\src\cmsis; ..\..\src\driver; ..\..\src\lib; ..\..\src\qnevb
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: eaci_controller.bin
  ILINK.IlinkOutputFile: eaci_controller.out
  ILINK.IlinkIcfFile: ..\..\src\link\iar\qn9020_link.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptStrategy: 0
  group aci_profiles
    ../src/: app_eaci_an.c app_eaci_batt.c app_eaci_blp.c app_eaci_csc.c app_eaci_dis.c app_eaci_fm.c app_eaci_gl.c app_eaci_hrp.c app_eaci_ht.c app_eaci_pas.c app_eaci_prx.c app_eaci_rsc.c app_eaci_sp.c app_eaci_time.c
  group app
    ../../src/app/anpc/: app_anpc.c app_anpc_task.c
    ../../src/app/anps/: app_anps.c app_anps_task.c
    ../../src/app/basc/: app_basc.c app_basc_task.c
    ../../src/app/bass/: app_bass.c app_bass_task.c
    ../../src/app/blpc/: app_blpc.c app_blpc_task.c
    ../../src/app/blps/: app_blps.c app_blps_task.c
    ../../src/app/cscpc/: app_cscpc.c app_cscpc_task.c
    ../../src/app/cscps/: app_cscps.c app_cscps_task.c
    ../../src/app/disc/: app_disc.c app_disc_task.c
    ../../src/app/diss/: app_diss.c app_diss_task.c
    ../../src/app/: app_env.c app_menu.c app_printf.c app_sys.c app_task.c app_util.c
    ../../src/app/findl/: app_findl.c app_findl_task.c
    ../../src/app/findt/: app_findt.c app_findt_task.c
    ../../src/app/gap/: app_gap.c app_gap_task.c
    ../../src/app/gatt/: app_gatt.c app_gatt_task.c
    ../../src/app/glpc/: app_glpc.c app_glpc_task.c
    ../../src/app/glps/: app_glps.c app_glps_task.c
    ../../src/app/hrpc/: app_hrpc.c app_hrpc_task.c
    ../../src/app/hrps/: app_hrps.c app_hrps_task.c
    ../../src/app/htpc/: app_htpc.c app_htpc_task.c
    ../../src/app/htpt/: app_htpt.c app_htpt_task.c
    ../../src/app/paspc/: app_paspc.c app_paspc_task.c
    ../../src/app/pasps/: app_pasps.c app_pasps_task.c
    ../../src/app/proxm/: app_proxm.c app_proxm_task.c
    ../../src/app/proxr/: app_proxr.c app_proxr_task.c
    ../../src/app/rscpc/: app_rscpc.c app_rscpc_task.c
    ../../src/app/rscps/: app_rscps.c app_rscps_task.c
    ../../src/app/scppc/: app_scppc.c app_scppc_task.c
    ../../src/app/scpps/: app_scpps.c app_scpps_task.c
    ../../src/app/smp/: app_smp.c app_smp_task.c
    ../../src/app/tipc/: app_tipc.c app_tipc_task.c
    ../../src/app/tips/: app_tips.c app_tips_task.c
  group drivers
    ../../src/driver/: dma.c gpio.c rtc.c serialflash.c sleep.c spi.c syscon.c timer.c uart.c
  group lib
    ../../src/lib/iar/: qn9020b2_lib_allroles.a
  group main
    ../../src/main/: app_main.c
  group profiles
    ../../src/profiles/anp/anpc/: anpc.c anpc_task.c
    ../../src/profiles/anp/anps/: anps.c anps_task.c
    ../../src/profiles/bas/basc/: basc.c basc_task.c
    ../../src/profiles/bas/bass/: bass.c bass_task.c
    ../../src/profiles/blp/blpc/: blpc.c blpc_task.c
    ../../src/profiles/blp/blps/: blps.c blps_task.c
    ../../src/profiles/cscp/cscpc/: cscpc.c cscpc_task.c
    ../../src/profiles/cscp/cscps/: cscps.c cscps_task.c
    ../../src/profiles/dis/disc/: disc.c disc_task.c
    ../../src/profiles/dis/diss/: diss.c diss_task.c
    ../../src/profiles/find/findl/: findl.c findl_task.c
    ../../src/profiles/find/findt/: findt.c findt_task.c
    ../../src/profiles/glp/glpc/: glpc.c glpc_task.c
    ../../src/profiles/glp/glps/: glps.c glps_task.c
    ../../src/profiles/hrp/hrpc/: hrpc.c hrpc_task.c
    ../../src/profiles/hrp/hrps/: hrps.c hrps_task.c
    ../../src/profiles/htp/htpc/: htpc.c htpc_task.c
    ../../src/profiles/htp/htpt/: htpt.c htpt_task.c
    ../../src/profiles/pasp/paspc/: paspc.c paspc_task.c
    ../../src/profiles/pasp/pasps/: pasps.c pasps_task.c
    ../../src/profiles/: prf_utils.c
    ../../src/profiles/prox/proxm/: proxm.c proxm_task.c
    ../../src/profiles/prox/proxr/: proxr.c proxr_task.c
    ../../src/profiles/rscp/rscpc/: rscpc.c rscpc_task.c
    ../../src/profiles/rscp/rscps/: rscps.c rscps_task.c
    ../../src/profiles/scpp/scppc/: scppc.c scppc_task.c
    ../../src/profiles/scpp/scpps/: scpps.c scpps_task.c
    ../../src/profiles/tip/tipc/: tipc.c tipc_task.c
    ../../src/profiles/tip/tips/: tips.c tips_task.c
  group qnevb
    ../../src/qnevb/: led.c
  group retarget
    ../../src/retarget/: retarget.c
  group startup
    ../../src/startup/iar/: startup.s
  group usr
    ../src/: app_eaci.c app_eaci_generic.c app_eaci_task_msg.c app_eaci_trans.c app_eaci_util.c system.c usr_design.c
