# IAR project observer.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: QN9020 Quintic QN9020
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: IAR_CC
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\src\fw; ..\..\src\profiles; ..\..\src\app; ..\..\src\app\gap; ..\..\src\app\gatt; ..\..\src\app\smp; ..\..\src\cmsis; ..\..\src\driver; ..\..\src\lib; ..\..\src\qnevb; ..\src
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: observer.bin
  ILINK.IlinkOutputFile: observer.out
  ILINK.IlinkIcfFile: ..\..\src\link\iar\qn9020_link.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptStrategy: 0
  group app
    ../../src/app/gap/: app_gap.c app_gap_task.c
    ../../src/app/: app_task.c app_util.c
  group drivers
    ../../src/driver/: gpio.c rtc.c serialflash.c sleep.c syscon.c timer.c uart.c
  group lib
    ../../src/lib/iar/: qn9020b2_lib_peripheral.a
  group main
    ../../src/main/: app_main.c
  group qnevb
    ../../src/qnevb/: button.c led.c
  group retarget
    ../../src/retarget/: retarget.c
  group startup
    ../../src/startup/iar/: startup.s
  group usr
    ../src/: system.c usr_design.c
