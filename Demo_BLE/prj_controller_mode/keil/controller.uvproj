# Keil uVision project controller.uvproj, settings and files
target controller (ARM-ADS)
  device: QN9020 Quintic
  cpu: IRAM(0x00008000-0x0000FFFF) IROM(0x00000000-0x00007FFF) CLOCK(16000000) CPUTYPE("Cortex-M0")
  output: controller
  AfterMake: fromelf --bin --output ./bin/controller.bin ./obj/controller.axf
  c flags: Optim=4 OneElfS=1
  c misc: --C99
  c include: ..\..\src\app;..\..\src\fw;..\..\src\cmsis;..\..\src\driver;..\..\src\lib;..\..\src\qnevb;..\src
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x8000 size 0x8000
  scatter file: ..\..\src\link\keil\qn9020_link.sct
  link misc: --no_autoat --remove
  group startup
    ../../src/startup/keil/: startup.s
  group main
    ../../src/main/: app_main.c
  group usr
    ../src/: system.c usr_design.c
  group drivers
    ../../src/driver/: uart.c gpio.c sleep.c syscon.c timer.c rtc.c spi.c serialflash.c
  group lib
    ../../src/lib/keil/: qn9020b2_lib_peripheral.lib
  group qnevb
    ../../src/qnevb/: led.c
  group retarget
    ../../src/retarget/: retarget.c
