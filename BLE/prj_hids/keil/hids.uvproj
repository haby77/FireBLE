# Keil uVision project hids.uvproj, settings and files
target hids (ARM-ADS)
  device: QN9020 NXP
  cpu: IRAM(0x00008000-0x0000FFFF) IROM(0x00000000-0x00007FFF) CLOCK(16000000) CPUTYPE("Cortex-M0")
  output: hids
  AfterMake: fromelf --bin --output ./bin/hids.bin ./obj/hids.axf
  c flags: Optim=4 OneElfS=1
  c misc: --C99
  c include: ..\..\src\fw;..\..\src\profiles;..\..\src\profiles\bas\bass;..\..\src\app;..\..\src\app\gap;..\..\src\app\gatt;..\..\src\app\smp;..\..\src\app\bass;..\..\src\cmsis;..\..\src\driver;..\..\src\lib;..\..\src\qnevb;..\src;..\..\src\app\diss;..\..\src\profiles\dis;..\..\src\profiles\hogp;..\..\src\profiles\hogp\hogpd;..\..\src\app\hogpd;..\..\src\profiles\dis\diss
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x8000 size 0x8000
  scatter file: ..\..\src\link\keil\qn9020_link.sct
  link misc: --no_autoat --remove
  group startup
    ../../src/startup/keil/: startup.s
  group main
    ../../src/main/: app_main.c
  group usr
    ../src/: system.c usr_design.c
  group app
    ../../src/app/: app_util.c app_env.c app_printf.c app_sys.c app_task.c
    ../../src/app/gap/: app_gap.c app_gap_task.c
    ../../src/app/gatt/: app_gatt.c app_gatt_task.c
    ../../src/app/smp/: app_smp.c app_smp_task.c
    ../../src/app/bass/: app_bass_task.c app_bass.c
    ../../src/app/diss/: app_diss.c app_diss_task.c
    ../../src/app/hogpd/: app_hogpd.c app_hogpd_task.c
  group profiles
    ../../src/profiles/: prf_utils.c
    ../../src/profiles/bas/bass/: bass_task.c bass.c
    ../../src/profiles/dis/diss/: diss.c diss_task.c
    ../../src/profiles/hogp/hogpd/: hogpd.c hogpd_task.c
  group drivers
    ../../src/driver/: uart.c gpio.c sleep.c syscon.c adc.c analog.c wdt.c timer.c rtc.c serialflash.c
  group lib
    ../../src/lib/keil/: qn9020b2_lib_peripheral.lib
  group qnevb
    ../../src/qnevb/: led.c button.c joysticks.c
  group retarget
    ../../src/retarget/: retarget.c
