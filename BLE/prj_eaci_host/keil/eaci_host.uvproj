# Keil uVision project eaci_host.uvproj, settings and files
target eaci_host (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: eaci_host +hex
  AfterMake: fromelf --bin --output ./bin/eaci_host.bin ./obj/eaci_host.axf
  c flags: Optim=1
  c misc: --C99
  c include: ..\src;..\src\cmsis;..\src\LPC17xx;..\src\driver;..\src\config;..\src\aci;..\..\src\fw;..\..\src\cmsis;..\..\src\driver;..\..\src\lib;..\..\src\qnevb;..\..\src\profiles;..\..\src\profiles\anp;..\..\src\profiles\anp\anpc;..\..\src\profiles\anp\anps;..\..\src\profiles\bas;..\..\src\profiles\bas\basc;..\..\src\profiles\bas\bass;..\..\src\profiles\blp;..\..\src\profiles\blp\blpc;..\..\src\profiles\blp\blps;..\..\src\profiles\cscp;..\..\src\profiles\cscp\cscpc;..\..\src\profiles\cscp\cscps;..\..\src\profiles\dis;..\..\src\profiles\dis\disc;..\..\src\profiles\dis\diss;..\..\src\profiles\find;..\..\src\profiles\find\findt;..\..\src\profiles\find\findl;..\..\src\profiles\glp;..\..\src\profiles\glp\glpc;..\..\src\profiles\glp\glps;..\..\src\profiles\hrp;..\..\src\profiles\hrp\hrps;..\..\src\profiles\hrp\hrpc;..\..\src\profiles\htp;..\..\src\profiles\htp\htpc;..\..\src\profiles\htp\htpt;..\..\src\profiles\pasp;..\..\src\profiles\pasp\paspc;..\..\src\profiles\pasp\pasps;..\..\src\profiles\prox;..\..\src\profiles\prox\proxm;..\..\src\profiles\prox\proxr;..\..\src\profiles\rscp;..\..\src\profiles\rscp\rscpc;..\..\src\profiles\rscp\rscps;..\..\src\profiles\scpp;..\..\src\profiles\scpp\scppc;..\..\src\profiles\scpp\scpps;..\..\src\profiles\tip;..\..\src\profiles\tip\tipc;..\..\src\profiles\tip\tips;..\src\app;..\..\src\app\anpc;..\..\src\app\anps;..\..\src\app\basc;..\..\src\app\bass;..\..\src\app\blpc;..\..\src\app\blps;..\..\src\app\cscpc;..\..\src\app\cscps;..\..\src\app\disc;..\..\src\app\diss;..\..\src\app\findl;..\..\src\app\findt;..\..\src\app\glpc;..\..\src\app\glps;..\..\src\app\hrpc;..\..\src\app\hrps;..\..\src\app\htpc;..\..\src\app\htpt;..\..\src\app\paspc;..\..\src\app\pasps;..\..\src\app\proxm;..\..\src\app\proxr;..\..\src\app\rscpc;..\..\src\app\rscps;..\..\src\app\scppc;..\..\src\app\scpps;..\..\src\app\tipc;..\..\src\app\tips
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group startup
    ../src/LPC17xx/startup/: startup_LPC17xx.s
  group drivers
    ../src/LPC17xx/: system_LPC17xx.c
    ../src/driver/: uart.c lpc17xx_spi.c lpc17xx_clkpwr.c lpc17xx_libcfg_default.c lpc17xx_pinsel.c lpc17xx_nvic.c lpc17xx_gpio.c
  group aci
    ../src/aci/: eaci.c eaci_uart.c
  group app
    ../src/app/: app_env.c app_sys.c app_util.c app_msg.c app_generic.c app_data.c app_menu.c
  group main
    ../src/main/: main.c
  group retarget
    ../../src/retarget/: retarget.c
