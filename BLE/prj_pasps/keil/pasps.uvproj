# Keil uVision project pasps.uvproj, settings and files
target pasps (ARM-ADS)
  device: QN9020 NXP
  cpu: IRAM(0x00008000-0x0000FFFF) IROM(0x00000000-0x00007FFF) CLOCK(16000000) CPUTYPE("Cortex-M0")
  output: pasps
  AfterMake: fromelf --bin --output ./bin/pasps.bin ./obj/pasps.axf
  c flags: Optim=4 OneElfS=1
  c misc: --C99
  c include: ..\..\src\fw;..\..\src\profiles;..\..\src\profiles\pasp;..\..\src\profiles\pasp\pasps;..\..\src\profiles\dis\diss;..\..\src\app;..\..\src\app\gap;..\..\src\app\gatt;..\..\src\app\pasps;..\..\src\app\smp;..\..\src\app\diss;..\..\src\cmsis;..\..\src\driver;..\..\src\lib;..\..\src\qnevb;..\src
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x8000 size 0x8000
  scatter file: ..\..\src\link\keil\qn9020_link.sct
  link misc: --no_autoat --remove
  group startup
    ../../src/startup/keil/: startup.s
  group main
    ../../src/main/: app_main.c
  group usr
    ../src/: system.c usr_design.c
  group app
    ../../src/app/: app_util.c app_env.c app_printf.c app_sys.c app_task.c
    ../../src/app/gap/: app_gap.c app_gap_task.c
    ../../src/app/gatt/: app_gatt.c app_gatt_task.c
    ../../src/app/smp/: app_smp.c app_smp_task.c
    ../../src/app/pasps/: app_pasps.c app_pasps_task.c
  group profiles
    ../../src/profiles/: prf_utils.c
    ../../src/profiles/pasp/pasps/: pasps.c pasps_task.c
  group drivers
    ../../src/driver/: uart.c gpio.c sleep.c syscon.c rtc.c timer.c wdt.c serialflash.c adc.c analog.c
  group lib
    ../../src/lib/keil/: qn9020b2_lib_peripheral.lib
  group qnevb
    ../../src/qnevb/: led.c button.c joysticks.c
  group retarget
    ../../src/retarget/: retarget.c
