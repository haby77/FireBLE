# Keil uVision project mpu6050.uvproj, settings and files
target uart (ARM-ADS)
  device: QN9020 Quintic
  cpu: IRAM(0x00008000-0x0000FFFF) IROM(0x00000000-0x00007FFF) CLOCK(16000000) CPUTYPE("Cortex-M0")
  output: mpu6050
  AfterMake: fromelf --bin --output ./bin/mpu_6050.bin ./obj/mpu6050.axf
  c flags: Optim=1
  c misc: --c99
  c include: ..\src;..\..\src\driver;..\..\src\fw;..\..\src\cmsis;..\..\src\lib
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x8000
  memory RVCT9: RAM 0x10008000 size 0x8000
  scatter file: ..\..\src\link\keil\qn9020_link.sct
  group startup
    ../../src/startup/keil/: startup.s
  group system
    ../src/: system.c
  group driver
    ../../src/driver/: dma.c gpio.c i2c.c rtc.c sleep.c syscon.c timer.c uart.c
    ../src/: mpu_6050.c
  group lib
    ../../src/lib/keil/: qn902xb2_lib_lite.lib
  group main
    ../src/: mpu6050_example.c
  group retarget
    ../src/: retarget.c
