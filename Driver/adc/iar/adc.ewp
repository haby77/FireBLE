# IAR project adc.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: QN9020 Quintic QN9020
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: IAR_CC
  ICCARM.CCDiagSuppress: Pa050,Pa082
  ICCARM.CCIncludePath2: ..\src; ..\..\src\driver; ..\..\src\fw; ..\..\src\cmsis; ..\..\src\lib
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: adc.bin
  ILINK.IlinkOutputFile: adc.out
  ILINK.IlinkIcfFile: ..\..\src\link\iar\qn9020_link.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group driver
    ../../src/driver/: adc.c analog.c dma.c gpio.c i2c.c pwm.c rtc.c serialflash.c sleep.c spi.c syscon.c timer.c uart.c wdt.c
  group lib
    ../../src/lib/iar/: qn902xb2_lib_lite.a
  group main
    ../src/: adc_example.c
  group retarget
    ../../src/retarget/: retarget.c
  group startup
    ../../src/startup/iar/: startup.s
  group system
    ../src/: system.c
